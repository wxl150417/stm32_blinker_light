# Keil uVision project Project-STC15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project-STC15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user;.\app
  group Source Group 1
    ./user/: main.c public.c
    ./app/: Sys_init.c LED.c STA_Machine.c
